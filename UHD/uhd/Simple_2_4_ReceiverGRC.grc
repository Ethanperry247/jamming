options:
  parameters:
    author: jonathan
    generate_options: no_gui
    id: Simple_2_4_Receiver
    output_language: python
    title: Simple 2.4 GHz Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '3840000'
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 2437e6
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '20000000'
    center_freq0: target_freq
    gain0: '50'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
