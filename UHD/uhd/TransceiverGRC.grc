options:
  parameters:
    author: jonathan
    generate_options: qt_gui
    id: Transceiver
    output_language: python
    title: Basic Transceiver
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: (1,0)
    label: Center Frequency
    type: real
    value: '95000000'
  states: {}
- name: gain_select
  id: variable_qtgui_range
  parameters:
    gui_hint: (0,1)
    label: Signal Sink Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3840000'
  states: {}
- name: sig_sink_bandwidth
  id: variable_qtgui_entry
  parameters:
    gui_hint: (0,0)
    label: Signal Sink Bandwidth
    type: real
    value: '200000'
  states: {}
- name: sig_sink_input_toggle_switch
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: (1,1)
    initPressed: 'False'
    label: Signal Sink Input
    pressed: '0'
    released: '1'
    type: bool
    value: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 192e3
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: '1000'
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: sig_sink_input_toggle_switch
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    gui_hint: (2,0,1,2)
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    gui_hint: (3,0)
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (3,1)
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '192'
    interp: '48'
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: sig_sink_bandwidth
    center_freq0: center_freq
    clock_rate: 30.72e6
    gain0: gain_select
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: '20'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', analog_wfm_tx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_selector_0, '1']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_tx_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', uhd_usrp_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
